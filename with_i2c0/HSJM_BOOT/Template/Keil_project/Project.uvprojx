# Keil uVision project Project.uvprojx, settings and files
target GD32A50x (6160000::V6.16::ARMCLANG)
  device: GD32A503KC GigaDevice
  pack: GigaDevice.GD32A50x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin --bincombined --bincombined_padding=1,0xff --output ../../outfile.bin  !L
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32A50X
  c include: ..\..\Utilities;..\..\Template;..\..\Firmware\GD32A50x_standard_peripheral\Include;..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32A50x\Include;..\..\Lib\Src;..\..\Lib\Inc;..\..\User\Inc;..\..\User\Src;..\..\Lib;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c systick.c gd32a50x_it.c fmc_App.c Update.c i2c_App.c Define.h MAX96752.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32A50x/Source/: system_gd32a50x.c
  group Peripherals
    ../../Firmware/GD32A50x_standard_peripheral/Source/: gd32a50x_adc.c gd32a50x_bkp.c gd32a50x_can.c gd32a50x_cmp.c gd32a50x_crc.c gd32a50x_dac.c gd32a50x_dbg.c gd32a50x_dma.c gd32a50x_exti.c gd32a50x_fmc.c gd32a50x_fwdgt.c gd32a50x_gpio.c gd32a50x_i2c.c gd32a50x_mfcom.c gd32a50x_misc.c gd32a50x_pmu.c gd32a50x_rcu.c gd32a50x_rtc.c gd32a50x_spi.c gd32a50x_syscfg.c gd32a50x_timer.c gd32a50x_trigsel.c gd32a50x_usart.c gd32a50x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32A50x/Source/ARM/: startup_gd32a50x.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.5.0
