# IAR project Project.ewp, settings and files
configuration GD32A50x (ARM, debug)
  General.OGChipSelectEditMenu: GD32A503xD GD GD32A503xD
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: GD32A50X
  ICCARM.CCIncludePath2: ..; ..\..\Utilities; ..\..\Firmware\GD32A50x_standard_peripheral\Include; ..\..\Firmware\CMSIS; ..\..\Firmware\CMSIS\GD\GD32A50x\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: gd32a50x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32A50x/Source/: system_gd32a50x.c
  group Doc
    ../: readme.txt
  group GD32A50x_EVAL
    ../../Utilities/: gd32a503v_eval.c
  group GD32A50x_Peripherals
    ../../Firmware/GD32A50x_standard_peripheral/Source/: gd32a50x_adc.c gd32a50x_bkp.c gd32a50x_can.c gd32a50x_cmp.c gd32a50x_crc.c gd32a50x_dac.c gd32a50x_dbg.c gd32a50x_dma.c gd32a50x_exti.c gd32a50x_fmc.c gd32a50x_fwdgt.c gd32a50x_gpio.c gd32a50x_i2c.c gd32a50x_mfcom.c gd32a50x_misc.c gd32a50x_pmu.c gd32a50x_rcu.c gd32a50x_rtc.c gd32a50x_spi.c gd32a50x_syscfg.c gd32a50x_timer.c gd32a50x_trigsel.c gd32a50x_usart.c gd32a50x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32A50x/Source/IAR/: startup_gd32a50x.s
